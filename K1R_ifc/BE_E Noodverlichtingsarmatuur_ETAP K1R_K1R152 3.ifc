Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-15T10:37:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 15 10:37:22 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{E5EF0ACD-DCF6-4EDD-BE4B-CAFADDE8EBA4}\ifc * Database version: 5507 * Database creation date: Wed Jun 15 10:37:22 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 15 10:37:22 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 15 10:37:22 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: K1R152 3, Dummy:K1R152 3:229474
In: Level 1
Type - Material: Glass
Type - Constraints - Default Elevation: 2000 mm; WT_H Behuizing hoogte: 38 mm; WT_H Behuizing hoogte_negatief: 0 mm; WT_H Breedte: 152 mm; WT_H Diameter: 1 mm; WT_H Geometrie: vierkant; WT_H Haakse wandmontage: no; WT_H Halve breedte: 76 mm; WT_H Halve breedte negatief: -76 mm; WT_H Halve hoogte negatief: -19 mm; WT_H Halve lengte negatief: -76 mm; WT_H Inbouw: no; WT_H Lengte: 152 mm; WT_H Lichtbron_z coordinaten: 0 mm; WT_H Opbouw: yes; WT_H Optiek: lens met signalisatie; WT_H Parallelle wandmontage: no; WT_H Permanent: no; WT_H Referentie: Opbouw; WT_H Signalisatiemogelijkheden_type: enkelzijdig (E) / dubbelzijdig (D); WT_H Straal pictogram: 0.5 mm; WT_H Verschuiving pictogram wand: 160 mm; WT_H Void_breedte: 152 mm; WT_H Void_lengte: 152 mm; WT_H Void_ronde: no; WT_H Void_straal: 1 mm
Type - Dimensions - BE_G Breedte: 152 mm; BE_G Diameter: 0 mm; BE_G Hoogte: 1235 mm; BE_G Lengte: 152 mm
Type - Electrical - BE_E Arbeidsfactor: 0.95; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 0 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 0 W
Type - Identity Data - BE_I Bestelcode: K1R152/3; Cost: 0; Description: Noodverlichtingsarmatuur; Manufacturer: Etap; Model: K1R; Type Name: K1R152 3; WT_I BaseKeynote: 68.8
Type - Materials and Finishes - WT_V Materiaal_optiek: Glass
Type - Model Properties - WT_I Autonomie: *60; WT_I Batterij type: NiMh 1,2V 1,1Ah; WT_I Kleur: RAL9003; WT_I Lamptype: Lamp Led; WT_I Optiek: lens; WT_I Permanent_Niet permanent: niet perm./perm.; WT_I Specifieke uitvoering: -; WT_I Uitvoering: opbouw; WT_I Werking: Decentraal systeem; WT_I Zelftest: EST+
Type - Other - Category: Lighting Fixtures; Family Name: Dummy
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP K1R - lichtbron - LED: K1R152_3_+K9RHL0S; WT_I Lumen: 70
Pset_ManufacturerTypeInformation - Manufacturer: Etap
Pset_DistributionFlowElementCommon - Reference: K1R152 3
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Rotatie pictogram: 0 deg; WT_H Rotatie pictogram wand: 180 deg
Construction - WT_V Pendelhoogte: 0 mm
Dimensions - Area: 0.576648 m2; Volume: 0.032924 m3
Electrical - WT_c1 Kringnummer: 0
Electrical - Circuiting - Electrical Data: c1_Power - Balanced 230 V/1-0 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Graphics - BE_G Pictogram: BE_G_ANN Pictogram: Geen; WT_I Signalisatiemogelijkheden: enkelzijdig (E) / dubbelzijdig (D); WT_V Pictogram andere richting: no
Identity Data - Mark: 71
Other - Family: Dummy: K1R152 3; Family and Type: Dummy: K1R152 3; Schedule Level: Level: Level 1; Type: Dummy: K1R152 3; Type Id: Dummy: K1R152 3
Phasing - Phase Created: 469492
